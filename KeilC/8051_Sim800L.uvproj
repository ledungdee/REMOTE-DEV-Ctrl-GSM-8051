# Keil uVision project 8051_Sim800L.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: 8051_Sim800L +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c uartmode1.c lcd.h lcd.c
